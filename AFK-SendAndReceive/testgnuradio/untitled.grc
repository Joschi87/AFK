options:
  parameters:
    author: adahlhoff
    generate_options: no_gui
    id: untitled
    output_language: python
    run_options: run
    title: ping
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("CLICK")
    period: '2500'
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5556
    timeout: '250'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [blocks_message_strobe_0, strobe, zeromq_pub_msg_sink_0, in]

metadata:
  file_format: 1
