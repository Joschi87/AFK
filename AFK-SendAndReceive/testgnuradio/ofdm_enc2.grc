options:
  parameters:
    author: adahlhoff
    generate_options: qt_gui
    id: ofdm_enc2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '3'
    min: '0'
    num_samps: '100'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '128'
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '10'
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    type: complex
    vlen: fft_len
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '20'
    type: byte
  states: {}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: complex
    vlen: '128'
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (0j+1,1j+0,0j-1,0-1j)
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: fft_len
    len_tag_key: '"packet_len"'
    occupied_carriers: ((4,5,6,7,9,10,11,12,14,15),)
    output_is_shifted: 'True'
    pilot_carriers: ((3,8,13),)
    pilot_symbols: ((1+0j,1+0j,1+0j),)
    sync_words: ((0j+-0.17,0j+0.29,0j+-0.66,0j+-0.62,0j+-0.97,0j+0.62,0j+0.58,0j+0.47,0j+-0.31,0j+0.33,0j+0.27,0j+-0.39,0j+0.19,0j+0.11,0j+-0.55,0j+-0.15,0j+0.42,0j+-0.17,0j+0.26,0j+-0.00,0j+-0.85,0j+0.86,0j+-0.46,0j+0.65,0j+0.26,0j+0.62,0j+0.40,0j+-0.06,0j+0.12,0j+-0.45,0j+0.57,0j+-0.76,0j+-0.88,0j+0.68,0j+-0.47,0j+-0.89,0j+-0.75,0j+-0.86,0j+-0.42,0j+-0.72,0j+-0.48,0j+0.79,0j+0.85,0j+-0.07,0j+0.57,0j+-0.87,0j+0.85,0j+-0.88,0j+0.85,0j+0.42,0j+-0.84,0j+0.82,0j+-0.26,0j+0.63,0j+-0.28,0j+-0.95,0j+0.81,0j+0.44,0j+0.77,0j+-0.60,0j+-0.07,0j+0.11,0j+0.53,0j+-0.84,0j+0.04,0j+-0.87,0j+-0.23,0j+0.38,0j+0.96,0j+0.45,0j+-0.43,0j+0.38,0j+0.21,0j+0.91,0j+-0.08,0j+-0.24,0j+0.85,0j+0.51,0j+0.52,0j+-0.96,0j+0.90,0j+0.04,0j+-0.28,0j+0.18,0j+-0.76,0j+0.38,0j+-0.02,0j+0.60,0j+-0.34,0j+-0.82,0j+0.98,0j+-0.33,0j+-0.55,0j+-0.41,0j+-0.62,0j+0.51,0j+0.04,0j+-0.08,0j+0.65,0j+0.17,0j+0.66,0j+-0.74,0j+-0.62,0j+-0.52,0j+0.81,0j+-0.13,0j+0.67,0j+0.85,0j+-0.77,0j+-0.27,0j+0.73,0j+1.00,0j+-0.81,0j+-0.90,0j+-0.59,0j+0.90,0j+-0.29,0j+0.33,0j+0.34,0j+0.52,0j+-0.61,0j+-0.37,0j+-0.27,0j+-0.35,0j+0.86,0j+0.23,0j+-0.05,0j+0.48),)
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'False'
    shift: 'True'
    type: complex
    window: ()
  states: {state: disabled}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tag_debug_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', digital_ofdm_carrier_allocator_cvc_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', blocks_tag_debug_0_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_null_sink_0, '0']
- [fft_vxx_0, '0', blocks_vector_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
